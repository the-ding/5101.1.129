#include "sys.h"
#include "modbus.h"
#include "db.h"

/* Table of CRC values for high–order byte */
static const  UINT8 auchCRCHi[] =
{
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81,
0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
0x40
} ;

/* Table of CRC values for low–order byte */
static const  UINT8 auchCRCLo[] =
{
0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4,
0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD,
0x1D, 0x1C, 0xDC, 0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32, 0x36, 0xF6, 0xF7,
0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE,
0x2E, 0x2F, 0xEF, 0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2,
0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB,
0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0, 0x50, 0x90, 0x91,
0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88,
0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83, 0x41, 0x81, 0x80,
0x40
} ;

/*****************************************************************************/
/* MODBUS校验和计算函数                                                      */
/*****************************************************************************/
UINT16 Modbus_crcH(UINT8 *Buff_addr,UINT16 len)
{
    UINT8 uchCRCHi = 0xFF ; // 初始化高字节
    UINT8 uchCRCLo = 0xFF ; // 初始化低字节
    UINT16 i, uIndex ; //CRC 表索引
    for(i=0;i<len;i++)
    {
        uIndex = uchCRCLo^Buff_addr[i];
        uchCRCLo= uchCRCHi^auchCRCHi[uIndex];
        uchCRCHi= auchCRCLo[uIndex];
    }
    return ((uchCRCHi<<8)|uchCRCLo);
}    

UINT16 Modbus_crc (const UINT8 *puchMsg, UINT16 usDataLen)
{
    UINT8   uchCRCHi = 0xFF;                            //high byte of CRC initialized 
    UINT8   uchCRCLo = 0xFF;                            // low byte of CRC initialized
    UINT8   uIndex;                                     // will index into CRC lookup table

    while (usDataLen--)                                 // pass through message buffer 
    {
        uIndex = uchCRCHi ^ *puchMsg++;                 // calculate the CRC 
        uchCRCHi = uchCRCLo ^ auchCRCHi[uIndex];
        uchCRCLo = auchCRCLo[uIndex];
    }
    return  ((UINT16)uchCRCHi << 8) | uchCRCLo;
}

/*****************************************************************************/
/* MODBUS接收处理函数，如果成功接收一帧数据则返回 (1)                        */
/*****************************************************************************/
void Modbus_recv (ModbusFrame *f, UINT8 ch)
{
    if (f->pos < MODBUS_BUFSZ)
    {
        f->buf[f->pos++] = ch;

        /*记录时标*/
        f->ticks = gSysTicks;
    }
}
//////////////////////////////////////////////////////////////////////////////
UINT8 Tcu_Crc (UINT8 *f,UINT8 n){
  
  UINT8 crc = *f,i;
  
  f++;
  
  for(i=1;i<n;i++)
    crc ^= *f++;
    
  return crc; 
}
/////////////////////////////////////////////////////////////////////////////
/*****************************************************************************/
/* MODBUS帧检查函数，判断帧是否接收完成，如果成功则返回 (1)                  */
/*****************************************************************************/

BOOL Modbus_check (ModbusFrame *f,UINT16 len)
{
    UINT16  crc;
    UINT16  calc;

   //四方充电机协议  
   if (f->pos == 0)
      return FALSE;

    if ((gSysTicks - f->ticks) < 5)
      return FALSE;

    if (f->pos != (f->buf[2] + 5))
    {
        f->pos = 0;
        return FALSE;
    }
    
    if((f->buf[0] != HEAD_485)
    || (f->buf[2] != len)
    || (f->buf[12] != END_485))
    {
        f->pos = 0;
        return FALSE;
    }    
    crc = f->buf[len+3];
    calc = Tcu_Crc((UINT8 *)&f->buf,len+3);  //txz000
    
    // 一、二级控制通信协议
    /*if (f->pos == 0)
      return FALSE;

    if ((gSysTicks - f->ticks) < 5)
      return FALSE;

    if ((f->pos < 7)||(f->buf[0]!=0x20)||((f->buf[2]&0x0f)!=(OEM_Para.bms_addr&0x0f)))
    {
        f->pos = 0;
        return FALSE;
    }
    
    crc = ((UINT16)f->buf[len] << 8) + f->buf[len + 1];
    calc = Modbus_crc (f->buf, len);
    */

    f->pos = 0;
    return crc == calc;
    
    
}



/*****************************************************************************/
/* MODBUS控制信息初始化                                                      */
/*****************************************************************************/
void Modbus_init (ModbusFrame *f)
{
    f->pos = 0;
}

